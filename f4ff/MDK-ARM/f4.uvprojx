# Keil uVision project f4.uvprojx, settings and files
target f4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../MPU6050;../MPU6050/eMPL;../PCA9548A;../onenet;../mqtt;../ICODE;../ESP8266;../CJSON;../oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c iwdg.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MPU6050
    ../MPU6050/: mpu6050.c
    ../MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group PCA9548
    ../PCA9548A/: pca9548.c
  group ICODE
    ../ICODE/: uart.c uart.h
  group ESP8266
    ../ESP8266/: esp8266.c esp8266.h
  group onenet
    ../onenet/: base64.c base64.h hmac_sha1.c hmac_sha1.h onenet.c onenet.h
  group mqtt
    ../mqtt/: Common.h MqttKit.c MqttKit.h SDK??????.txt
  group oled
    ../oled/: OLED.c OLED.h OLED_Font.h
  group CJSON
    ../CJSON/: cJSON.c cJSON.h
software components: CMSIS:CORE 4.3.0
